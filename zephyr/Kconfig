## zephyr/Kconfig
```kconfig
config AMPOULE_PROTOS
    bool "Enables the compilation of ampoule protobuf"
    default n
    select NANOPB
```
